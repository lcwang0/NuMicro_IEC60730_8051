# IAR project IEC60730.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: MS51_32K MS51_32K
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\..\Library\StdDriver; ..\..\..\..\Library\Device\Include; ..\..\..\IEC60730_8051_STL; ..; ..\..\..\..\Library\StdDriver\inc
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: iec_MS51_32K.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: N76E003 N76E003
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
  group IEC60730_SAFTEY_TEST_LIB
    ../../../IEC60730_8051_STL/: adc_mux_test_runtime.c cpureg_test.c flash_test_runtime.c flash_test_startup.c global_var.c interrupt_test_runtime.c pc_test_startup.c ram_march_test.c stack_test_runtime.c
    ../: checksum_table.c
  group IEC60730_SARETY_CONTROL
    ../../../IEC60730_8051_STL/: CLASSB_RUNTIME_TESTS.c CLASSB_STARTUP_TESTS.c CLASSB_TESTLIB_INIT.c IEC60730_SAFETY_TEST_LIB.c
  group Library
    ../../../../Library/StdDriver/src/: putchar.c sys.c uart.c
  group Startup
    ../../../../Library/Startup/IAR/: cstartup.s51
  group User
    ../: main.c system_init.c
