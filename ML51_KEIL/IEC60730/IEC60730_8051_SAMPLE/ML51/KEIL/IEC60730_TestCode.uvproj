# Keil uVision project IEC60730_TestCode.uvproj, settings and files
target IEC60730_TestCode (MCS-51)
  device: ML51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: IEC60730_ClassB_Test +hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc;..\..\ML51
  group User
    ../: system_init.c main.c
    ../../../../Library/Startup/Keil/: STARTUP.A51
  group IEC60730_SAFETY_TEST_LIB
    ../../../IEC60730_8051_STL/: adc_mux_test_runtime.c flash_test_runtime.c flash_test_startup.c global_var.c interrupt_test_runtime.c pc_test_startup.c ram_march_test.c stack_test_runtime.c cpureg_test.c
    ../: checksum_table.c
  group IEC60730_SAFETY_CONTROL
    ../../../IEC60730_8051_STL/: CLASSB_RUNTIME_TESTS.c CLASSB_TESTLIB_INIT.c CLASSB_STARTUP_TESTS.c IEC60730_SAFETY_TEST_LIB.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c uart.c common.c
